# Keil uVision project Rafael_BLE_ADV_DEMO.uvprojx, settings and files
target Rafael_BLE_ADV_DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F032R8T6 MindMotion
  pack: MindMotion.MM32F032_DFP.1.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Rafael_BLE_F032S_ADV_DEMO +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --text -c "$L@L.axf" --output "$L@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\APP\inc;..\APP\rf_source\rf_include;..\BSP\inc;..\Peripheral\inc;..\porting;..\..\..\2_Device\MM32F032xx_s\HAL_lib\inc;..\..\..\2_Device\MM32F032xx_s\Include;..\..\..\2_Device\CMSIS\KEIL_CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../2_Device/MM32F032xx_s/Source/: system_MM32F032xx_s.c
    ../../../2_Device/MM32F032xx_s/Source/KEIL_StartAsm/: startup_MM32F032xx_s_KEIL.s
  group APP
    ../APP/: main.c
    ../APP/rf_source/: kernel.c LL.c LL_open.c rf_phy.c
  group Peripheral
    ../Peripheral/: spi.c systick.c uart.c
  group BSP
    ../BSP/: bsp_irq_gpio.c bsp_spi_ble.c
  group HAL_LIB
    ../../../2_Device/MM32F032xx_s/HAL_lib/src/: HAL_i2c.c HAL_adc.c HAL_ver.c HAL_gpio.c HAL_tim.c HAL_rcc.c HAL_bkp.c HAL_crc.c HAL_dbg.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rtc.c HAL_spi.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group README
    ../: readme.txt
